Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-03T11:46:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 03 11:46:22 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{471F4B81-7A91-4EC4-9FBB-823A579E27B7}\ifc * Database version: 5507 * Database creation date: Fri Nov 03 11:46:20 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 03 11:46:20 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 03 11:46:20 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors, 12405374003:dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors:194158
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: AISI 304
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - AllowedLeafThickness: 33 - 59 mm; C-CDistance: 30/38; ClassificationGradesMinimumCategoryOfUse: EN 1906 - 4; ClassificationGradesMinimumCorrosionResistance: EN 1906 - 4: Very high resistance (240-hr salt-spray test); ClassificationGradesMinimumDoorMass: EN 1906 - No classification; ClassificationGradesMinimumDurability: EN 1906 - 7: 200 000 cycles; ClassificationGradesMinimumFireResistance: EN 1906 - B1: Suitable for use on fire/smoke door assemblies (tested with 200,000 test cycles on a test door); ClassificationGradesMinimumSafety: EN 1906 - 1: Safety applications; ClassificationGradesMinimumSecurity: EN 1906 - 0: Furniture not approved for use on burglary resistand doors; ClassificationGradesMinimumTypeOfOperation: EN 1906 - U: Unsprung furniture; RoseType: Snap on; Spindle: 8 x 8 x 92 mm
Type - Dimensions - DoorLeafThickness: 40 mm; HandleClearance: 35 mm; HandleLength: 114 mm; HandleThickness: 38 mm; RoseDiameter: 50 mm; RoseHeight: 4.01092 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Door lever handle sets; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-60/315; NBSTypeID: n/a; OmniclassCode: 22-08 71 00; OmniclassDescription: Door Hardware; ProductFamily: Hardware; ProductGroup: Lever handles; ProductInformation: http://dline.com/product/arne-jacobsen-collection-lever-handle-large/?attribute_pa_material=satin-stainless-steel-aisi-304&attribute_pa_item=snap-on-cover-3038mm-33-59mm-large-ss#; ProductionCountry: Lithuania; ProductSKU: 12405374003; Revision: n/a; Uniclass2015Code: Pr_30_36_59_25; Uniclass2015Title: Door lever handle sets; Uniclass2015Version: Products v1.5; UNSPSCCode: 31162801; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Arne Jacobsen design, stainless AISI 304 steel lever handle set, on snap on roses with c-c 30/38 mm distance and 8x8 mm spindle for doors with leaf thickness of 33-59 mm; Manufacturer: info@dline.com; Product certificate: SKG.0232.3647.04.ENG; Type Mark: 22; Type Name: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors
Type - Materials and Finishes - MainMaterial: AISI 304
Type - Other - AccessibilityPerformance: n/a; AssetType: fixed; Category: Pr_30_36_59_25:Door lever handle sets; CodePerformance: EN 1906; Color: Steel; Constituents: 1x AJ lever handle, 111 mm, brass, left hand; 1x AJ lever handle, 111 mm, brass, right hand; 2x Ball bearing rose, 50 mm, cc 30/38 mm, stainless steel; 1x Spindle 8 x 8 x 92 mm; 2x Grub screw M5x8.3 mm; 2x Sectioned bolt with bushings, M4x75 mm, brass; 2x Spacer; 2x Snap on cover, stainless steel;; DurationUnit: year; ExpectedLife: 20 years; Family Name: 12405374003; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 304 stainless steel; ModelNumber: n/a; ModelReference: 45-25-60/315; Name: LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors; ReplacementCost: n/a; Shape: n/a; Size: 194 x 139 x 50 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 195.105 mm; OverallWidth: 139 mm
Pset_DoorCommon - Reference: n/a; IsExternal: no; FireRating: EN 1906 - B1: Suitable for use on fire/smoke door assemblies (tested with 200,000 test cycles on a test door); AcousticRating: n/a; SecurityRating: EN 1906 - 0: Furniture not approved for use on burglary resistand doors; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: 45-25-60/315; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.00454017 m2; Volume: 0.0000157282 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Doors; Family: 12405374003: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors; Family and Type: 12405374003: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 12405374003: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors; Type Id: 12405374003: dline_Hardware_LeverHandles_AJ111_StainlessSteel_SnapOnRose_cc30/38_8x8mmSpindle_33-59mmThicknessDoors; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
